## main/Kconfig.projbuild
```kconfig
menu "Mod CAN Logger"

comment "Configuration WiFi/API via config.h (voir config_exemple.h)"

endmenu
```
